options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: Transmisor_SSB
    output_language: python
    title: Transmisor_SSB
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud modulante
    start: '0'
    step: '100E-6'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '100E-6'
    stop: '1'
    value: '100E-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coefiente Ka
    start: '0'
    step: '100E-6'
    stop: '4'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: Calculo_Potencia_Comunicaciones_0
  id: Calculo_Potencia_Comunicaciones
  parameters:
    I_vect: '1024'
  states: {}
- name: Modulador_SSB_0
  id: Modulador_SSB
  parameters:
    Ac: Ac
    K: K
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '20000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulador_SSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Calculo_Potencia_Comunicaciones_0, '0']
- [analog_sig_source_x_0, '0', Modulador_SSB_0, '0']

metadata:
  file_format: 1
