options:
  parameters:
    author: Fabian y kevin
    copyright: UIS
    generate_options: qt_gui
    id: Modulacion_PM_J1C_04
    output_language: python
    title: Modulacion PM J1C04
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Ampliud portadora
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitur mensaje
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuncia mensaje
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: CalculoPotencia_J1C_04_0
  id: CalculoPotencia_J1C_04
  parameters:
    l_vect: '1024'
  states: {}
- name: Envolvente_Compleja_PM_J1C_0
  id: Envolvente_Compleja_PM_J1C
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_Compleja_PM_J1C_0, '0', blocks_complex_to_mag_0, '0']
- [Envolvente_Compleja_PM_J1C_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_Compleja_PM_J1C_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_Compleja_PM_J1C_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_Compleja_PM_J1C_0, '0']
- [blocks_complex_to_mag_0, '0', CalculoPotencia_J1C_04_0, '0']

metadata:
  file_format: 1
