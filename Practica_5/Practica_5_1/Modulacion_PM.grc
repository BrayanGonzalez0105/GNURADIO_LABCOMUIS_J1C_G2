options:
  parameters:
    author: BRAYAN_GONZALEZ
    copyright: UIS
    description: Potencia_Envolvente_Compleja
    generate_options: qt_gui
    id: MODULACION_PM
    output_language: python
    title: MODULACION_PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la Portadora
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del Mensaje
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: 1e3
    step: '100'
    stop: 20e3
    value: 1e3
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: ENVOLVENTE_COMPLEJA_PM_J1C_0
  id: ENVOLVENTE_COMPLEJA_PM_J1C
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [ENVOLVENTE_COMPLEJA_PM_J1C_0, '0', blocks_complex_to_mag_0, '0']
- [ENVOLVENTE_COMPLEJA_PM_J1C_0, '0', qtgui_freq_sink_x_0, '0']
- [ENVOLVENTE_COMPLEJA_PM_J1C_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', ENVOLVENTE_COMPLEJA_PM_J1C_0, '0']
- [blocks_complex_to_mag_0, '0', CalculoPotenciaComunicaciones_0, '0']

metadata:
  file_format: 1
