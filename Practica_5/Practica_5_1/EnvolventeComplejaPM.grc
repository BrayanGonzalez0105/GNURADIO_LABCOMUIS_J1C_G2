options:
  parameters:
    author: EstudiantesUIS
    category: '[Modulos_J1C_02 ]'
    copyright: UIS
    description: ModulodesarrolladoparaestudiarlaenvolventecomplejadeunaPM
    generate_options: hb
    id: EnvolventeComplejaPM
    output_language: python
    title: EnvolventeComplejaPMJ1C
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: AmplituddePortadora
    type: eng_float
    value: '100E-3'
  states: {}
- name: Kp
  id: parameter
  parameters:
    label: CoeficienteModulacionPM
    type: eng_float
    value: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: cos
    type: float
  states: {}
- name: blocks_transcendental_1
  id: blocks_transcendental
  parameters:
    name: sin
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_1, '0']
- [blocks_multiply_const_vxx_1, '0', pad_sink_0, '0']
- [blocks_transcendental_0, '0', blocks_float_to_complex_0, '0']
- [blocks_transcendental_1, '0', blocks_float_to_complex_0, '1']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
