options:
  parameters:
    author: Brayan_Gonzalez
    copyright: UIS
    description: Practica_5_1_2
    generate_options: qt_gui
    id: Modulacion_PM_2
    output_language: python
    title: Modulacion_PM_2
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la Portadora
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del Mensaje
    start: '0'
    step: '1'
    stop: '50'
    value: '1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: FRecuencia de la Portadora
    start: 50e6
    step: 1e6
    stop: 2e9
    value: 50e6
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de Mensaje
    start: 1e3
    step: '100'
    stop: 20e3
    value: 1e3
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del Transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: ENVOLVENTE_COMPLEJA_PM_J1C_0
  id: ENVOLVENTE_COMPLEJA_PM_J1C
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ENVOLVENTE_COMPLEJA_PM_J1C_0, '0', qtgui_freq_sink_x_0, '0']
- [ENVOLVENTE_COMPLEJA_PM_J1C_0, '0', qtgui_time_sink_x_0, '0']
- [ENVOLVENTE_COMPLEJA_PM_J1C_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ENVOLVENTE_COMPLEJA_PM_J1C_0, '0']

metadata:
  file_format: 1
