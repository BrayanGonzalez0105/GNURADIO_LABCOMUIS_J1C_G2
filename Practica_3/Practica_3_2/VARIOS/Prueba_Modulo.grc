options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: Prueba_Modulo
    output_language: python
    title: Prueba_Modulo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Calculo_Potencia_Comunicaciones_0
  id: Calculo_Potencia_Comunicaciones
  parameters:
    I_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [analog_sig_source_x_0, '0', Calculo_Potencia_Comunicaciones_0, '0']

metadata:
  file_format: 1
